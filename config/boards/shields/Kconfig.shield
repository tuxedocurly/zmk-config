## config/boards/shields/vcmacropad/Kconfig.defconfig
```kconfig
if SHIELD_VCMACROPAD

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "VC MacroPad"

endif
```
